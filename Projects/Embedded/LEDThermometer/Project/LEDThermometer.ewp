# IAR project LEDThermometer.ewp, settings and files
configuration LEDThermometer (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x4 ST STM32F030x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../Inc; ../../../../Source/Common define; ../../../../Source/Library/GPIOfun; ../../../../Source/Library/TIMDelay; ../../../../Source/Devices/MBI5039; ../../../../Source/Devices/DS18B20; ../../../../Source/Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Inc; ../../../../Source/Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Inc/Legacy; ../../../../Source/Drivers/STM32F0xx/CMSIS/Device/ST/STM32F0xx/Include; ../../../../Source/Drivers/STM32F0xx/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LEDThermometer.srec
  ILINK.IlinkOutputFile: LEDThermometer.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Device
    ../Src/: AlcoholColumn.c
    ../../../../Source/Devices/DS18B20/: DeviceDS18B20.c
    ../../../../Source/Devices/MBI5039/: DeviceMBI5039.c
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../../../../Source/Library/GPIOfun/: GPIOfun.c
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
    ../../../../Source/Library/TIMDelay/: TIMDelay.c
    ../../../../Source/Common define/: TypesDefine.h
  group Drivers/CMSIS
    ../../../../Source/Drivers/STM32F0xx/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Source/Drivers/STM32F0xx/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c
